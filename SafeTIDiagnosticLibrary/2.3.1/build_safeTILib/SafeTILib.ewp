# IAR project SafeTILib.ewp, settings and files
configuration Debug_RM48_LE (ARM, debug)
  General.OGChipSelectEditMenu: RM48L950ZWT TexasInstruments RM48L950ZWT
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: _RM48x_; _VFP_SUPPORT_=1
  ICCARM.CCIncludePath2: ..\safety_library\source\; ..\safety_library\include\; ..\hal\include\
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: _RM48x_; _VFP_SUPPORT_=1
  AARM.AUserIncludes: as above
  ILINK.IlinkOutputFile: SafeTILib.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Debug_RM46_LE (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: RM46L852ZWT TexasInstruments RM46L852ZWT
  ICCARM.CCDefines: _RM46x_; _VFP_SUPPORT_=1
  AARM.ADefines: _RM46x_; _VFP_SUPPORT_=1
configuration Debug_RM42_LE (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: RM42L432PZ TexasInstruments RM42L432PZ
  ICCARM.CCDefines: _RM42x_
  AARM.ADefines: _RM42x_
configuration Debug_TMS570LS04_BE (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: RM42L432PZ TexasInstruments RM42L432PZ
  ICCARM.CCDefines: _TMS570LS04x_
  AARM.ADefines: _TMS570LS04x_
configuration Debug_TMS570LS31_BE (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: TMS570LS3137ZWT TexasInstruments TMS570LS3137ZWT
  ICCARM.CCDefines: _TMS570LS31x_; _VFP_SUPPORT_=1
  AARM.ADefines: _TMS570LS31x_; _VFP_SUPPORT_=1
configuration Debug_TMS570LS12_BE (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: TMS570LS1227ZWT TexasInstruments TMS570LS1227ZWT
  ICCARM.CCDefines: _TMS570LS12x_; _VFP_SUPPORT_=1
  AARM.ADefines: _TMS570LS12x_; _VFP_SUPPORT_=1
  group hal/include
    ../hal/include/: reg_bitdefn_adc.h reg_bitdefn_can.h reg_bitdefn_ccmr4f.h reg_bitdefn_ccmr5f.h reg_bitdefn_dcc.h reg_bitdefn_dma.h reg_bitdefn_efc.h reg_bitdefn_epc.h reg_bitdefn_esm.h reg_bitdefn_f021flash.h reg_bitdefn_iomm.h reg_bitdefn_l2ramw.h reg_bitdefn_mibspi.h reg_bitdefn_pbist.h reg_bitdefn_pmm.h reg_bitdefn_rti.h reg_bitdefn_stc.h reg_bitdefn_system.h reg_bitdefn_tcmram.h reg_bitdefn_vim.h sl_hal_stdtypes.h sl_reg_adc.h sl_reg_can.h sl_reg_dcc.h sl_reg_dma.h sl_reg_efc.h sl_reg_epc.h sl_reg_esm.h sl_reg_flash.h sl_reg_gio.h sl_reg_l2ramw.h sl_reg_mibspi.h sl_reg_pbist.h sl_reg_pmm.h sl_reg_rti.h sl_reg_stc.h sl_reg_system.h sl_reg_tcram.h sl_reg_vim.h sl_sys_common.h sl_sys_vim.h
  group safety_library/include
    ../safety_library/include/: sl_api.h sl_config.h sl_log.h sl_types.h
  group safety_library/source
    ../safety_library/source/: sl_asm_api_IAR.asm sl_asm_IAR.inc sl_esm.c sl_init.c sl_log.c sl_misc.c sl_pmu_IAR.asm sl_priv.c sl_priv.h sl_selftest.c sl_sys_pmu.h
